# IAR project Audio.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E103xB GD GD32E103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32E10X; GD32E103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32E10x\Include; ..\..\..\..\..\Firmware\GD32E10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_driver\Include; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Audio.srec
  ILINK.IlinkOutputFile: Project.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32E103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c audio_core.c gd32e10x_audio_codec.c gd32e10x_it.c usb_delay.c usbd_audio_out_if.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/IAR/: startup_gd32e10x.s
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Doc
    ../: readme.txt
  group GD32E10x_EVAL
    ../../../../../Utilities/: gd32e10x_eval.c
  group GD32E10x_StdPeriph
    ../../../../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_dma.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c
  group USBFS_Driver
    ../../../../../Firmware/GD32E10x_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
